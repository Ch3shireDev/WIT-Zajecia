#include<stdio.h>
#include<stdlib.h>
/*********************************************************************************/
/*********************************************************************************/
int MyRead();
void BlackLine(int);
void GrowLine(int);
void Triangle1(int);
void Triangle2(int);
void MyFig(int, void(*mF)(int));
/*********************************************************************************/
/*********************************************************************************/
int MyRead(){
    int x;

    printf("x ?=");
    scanf("%d", &x);

    return x;
    }
/*********************************************************************************/
void BlackLine(int x){
    int i;
    for(i=0;i<x;++i)
        printf("* ");
    }
/*********************************************************************************/
void GrowLine(int x){
    int i,j;
    for(i=0;i<x;++i){
        for(j=0;j<=i;++j)
            printf("_ ");
        for(j=0;j<=i;++j)
            printf("* ");
        }
    }
/*********************************************************************************/
void Triangle1(int x){
    int i;
    for(i=0;i<x;++i){
        BlackLine(i+1);
        printf("\n");
        }
    }
/*********************************************************************************/
void Triangle2(int x){
    int i;
    for(i=0;i<x;++i){
        BlackLine(x-i);
        printf("\n");
        }
    }
/*********************************************************************************/
void MyFig(int x, void(*mF)(int)){
    int i;
    for(i=0;i<x;++i){
        mF(x);
        printf("\n");
        }
    }
/*********************************************************************************/
/*********************************************************************************/
int main(){
    int x;

    x=MyRead();

    MyFig(x, BlackLine);
    MyFig(x, GrowLine);
    MyFig(x, Triangle1);
    MyFig(x, Triangle2);

/** 6b, 7b, 8b
x ?= 3
* * *
* * *
* * *

_ * _ _ * * _ _ _ * * *
_ * _ _ * * _ _ _ * * *
_ * _ _ * * _ _ _ * * *

*
* *
* * *

*
* *
* * *

*
* *
* * *

* * *
* *
*

* * *
* *
*

* * *
* *
*


*/


    return 0;
    }

