#include <stdio.h>
/************************************************************************/
/************************************************************************/
int MyRead();
void WhiteLine(int);
void BlackLine(int);
void MySquare(int);
void MyTriangle(int);
/**  3b, 4b, 5b
x ?= 5
* * * * *
  * * * *
    * * *
      * *
        *

*/
/************************************************************************/
/************************************************************************/
int MyRead(){
    int x;
    printf("x ?=");
    scanf("%d", &x);

    return x;
    }
/************************************************************************/
void WhiteLine(int x){
    int j;
    for(j=0;j<x;++j)
        printf("  ");
    }
/************************************************************************/
void BlackLine(int x){
    int j;
    for(j=0;j<x;++j)
        printf("* ");
    }
/************************************************************************/
void MySquare(int x){
    int j;
    for(j=0;j<x;++j){
        BlackLine(x);
        printf("\n");
        }
    }
/************************************************************************/
void MyTriangle(int x){
    int j;
    for(j=0;j<x;++j){
        WhiteLine(j);
        BlackLine(x-j);
        printf("\n");
        }
    }
/************************************************************************/
/************************************************************************/
int main(){
    MyTriangle(MyRead());

    return 0;
    }
