#include<stdio.h>
#include<stdlib.h>
/************************************************************************/
/************************************************************************/
int MyRead();
void MyFig(int, void(*mF)(int));
void MyLine(int);
void GrowLine(int);
void Triangle1(int);
void Trapeze(int);
/************************************************************************/
/************************************************************************/
int MyRead(){
    int x;
    printf("x ?=");
    scanf("%d", &x);

    return x;
    }
/** 3b, 4b, 5b
x ?= 3
* * *
* * *
* * *

 *  **   ***
 *  **   ***
 *  **   ***

* * *
* *
*

* * *
* *
*

* * *
* *
*

*/

/************************************************************************/
void MyFig(int x, void(*mF)(int)){
    int i;
    for(i=0;i<x;++i){
        mF(x);
        printf("\n");
        }
    }
/************************************************************************/
void MyLine(int x){
    int i;
    for(i=0;i<x;++i)
        printf("* ");
    }
/************************************************************************/
void GrowLine(int x){
    int i, j;
    for(i=0;i<x;++i){
        for(j=0;j<=i;++j)
            printf("  ");
        for(j=0;j<=i;++j)
            printf("* ");
        }
    }
/************************************************************************/
void Triangle1(int x){
    int i;
    for(i=0;i<x;++i){
        MyLine(x-i);
        printf("\n");
        }
    }
/************************************************************************/
void Trapeze(int x){
    int i;
    for(i=0;i<x;++i){
        MyLine(2*x-i);
        printf("\n");
        }
    }
/************************************************************************/
/************************************************************************/
int main(){
    int x;
    x = MyRead();

    MyFig(x, MyLine);
    MyFig(x, GrowLine);
    MyFig(x, Triangle1);
    MyFig(x, Trapeze);

    return 0;
    }
